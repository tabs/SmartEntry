# Keil uVision project SmartEntry下板.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SmartEntry下板 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Assembly
    ./: STARTUP.A51
  group SOURCES
    ./: FlashFunction.c init.c UtilsFunction.c
